## tests/zephyr_apps/54_aar_ccm_ecb/testcase.yaml
```yaml
tests:
  boards.nrf54l15bsim.aes_ccm_ecb:
    platform_allow:
      - nrf54l15bsim/nrf54l15/cpuapp
```
